Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: a1780eb8-e0f3-4a15-b6ec-0bde06a1e91d.ifc
Time: 2026-08-11T15:50:08
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Elektrisch 700 x 1300mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAGwZm8AGAAAA9OsCAAWxXwAAPHsBAHQGAACn7AIADOwCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAbOsCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAJFYAAAFabkAAGQwAADGpwAAo60AAL8lAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAGwZm8AGAAAA9OsCAAWxXwAAPHsBAHQGAACn7AIADOwCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAbOsCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAJFYAAAFabkAAGQwAADGpwAAo60AAL8lAAAAAA)); STABU2: 32.32.11; lengte: 1280 mm; inbouwhoogte: 240 mm; inbouwlengte: 1300 mm; luchtdoorlatendheid klasse: 4; U-waarde: 0,58 w/m²·k; breedte: 680 mm; max. belasting: 200 kg; NAA.K.T: samengesteld_product_generiek; bediening: elektrisch; theoretische levensduur: 50; serie: Schaartrap Elektrisch; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; omranding: hout; luik: hout; trap: schaarladder Storax - Schaarladder 300mm
